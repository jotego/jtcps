File: cores/cps3/sch/gll2.kicad_sch (KiCad schematic)
At the start: 3 parts

Commit message: wip_cassette_sh2
Other:
- moved on the sheet: G8, JP1, R10
