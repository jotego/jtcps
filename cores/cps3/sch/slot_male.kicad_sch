File: cores/cps3/sch/slot_male.kicad_sch (KiCad schematic)
At the start: 12 parts

Commit message: wip_ccu_cassette
Other:
- moved on the sheet: SIMM1E, SIMM2D, SIMM5CC, SIMM6BB
