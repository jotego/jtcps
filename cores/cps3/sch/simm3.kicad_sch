File: cores/cps3/sch/simm3.kicad_sch (KiCad schematic)
At the start: 8 parts

Commit message: wip_cassette_sh2
Other:
- moved on the sheet: JE1, JE2, JE3, JE4, JE5, JE6, JE7, JE8
